# Keil uVision project G431_Template.uvprojx, settings and files
target G431_Template (ARM-ADS)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: G431_Template +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32G431xx
  c include: ..\..\Inc;..\..\Private;..\..\..\Common\Inc;..\..\CMSIS\Device\Include;..\..\CMSIS\Core\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./: main.c
  group eSPL
    ../../Src/: stm32g4_check.c stm32g4_flash.c stm32g4_gpio.c stm32g4_pwr.c stm32g4_rcc.c stm32g4_usart.c
  group CMSIS_Device
    ../../CMSIS/Device/Source/: system_stm32g4xx.c
    ../../CMSIS/Device/Source/startup/arm/: startup_stm32g431xx.s
