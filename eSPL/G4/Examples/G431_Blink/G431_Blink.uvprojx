# Keil uVision project G431_Blink.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: G431_Blink
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32G431xx
  c include: ..\..\Inc;..\..\Private;..\..\CMSIS\Device\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group SPL
    ../../Src/: stm32g4_check.c stm32g4_gpio.c stm32g4_rcc.c stm32g4_usart.c stm32g4_tim.c stm32g4_dma.c stm32g4_dmamux.c stm32g4_spi.c stm32g4_adc.c stm32g4_i2c.c stm32g4_fdcan.c
  group Application
    ./: main.c
  group CMSIS_Device
    ../../CMSIS/Device/Source/: system_stm32g4xx.c
    ../../CMSIS/Device/Source/startup/arm/: startup_stm32g431xx.s
software components: CMSIS:CORE 5.5.0
