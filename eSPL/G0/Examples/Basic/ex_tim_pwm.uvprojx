# Keil uVision project ex_tim_pwm.uvprojx, settings and files
target eSPL_examples (6220000::V6.22::ARMCLANG)
  device: STM32G0B1RETx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00024000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ex_tim_pwm +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32G0B1xx, SPL_CHECK_LEVEL=0
  c include: ..\..\Inc;..\..\Private;..\..\CMSIS\Core\Include;..\..\CMSIS\Device\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group eSPL_Driver
    ../../Src/: stm32g0_gpio.c stm32g0_rcc.c stm32g0_flash.c stm32g0_pwr.c stm32g0_nvic.c stm32g0_syscfg.c stm32g0_dbgmcu.c stm32g0_usart.c stm32g0_spi.c stm32g0_i2c.c stm32g0_dma.c stm32g0_dmamux.c stm32g0_crc.c stm32g0_check.c stm32g0_iwdg.c stm32g0_wwdg.c stm32g0_crs.c stm32g0_tim.c stm32g0_lptim.c stm32g0_rtc.c stm32g0_exti.c stm32g0_adc.c stm32g0_dac.c stm32g0_comp.c stm32g0_vrefbuf.c stm32g0_fdcan.c stm32g0_fdcan_layout.c stm32g0_aes.c stm32g0_rng.c stm32g0_cec.c stm32g0_ucpd.c stm32g0_mpu.c
  group Application
    ./: ex_tim_pwm.c ex_board.c
  group CMSIS_Device
    ../../CMSIS/Device/Source/: system_stm32g0xx.c
    ../../CMSIS/Device/Source/startup/arm/: startup_stm32g0b1xx.s
